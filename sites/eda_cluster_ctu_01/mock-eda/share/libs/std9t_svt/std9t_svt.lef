# std9t_svt standard-cell library, tt0p90v25c, 9-track SVT (MOCK library of the demo Site eda_cluster_ctu_01)
# Generated from the mock EDA design model; not a foundry library, not for signoff.
VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO DFFQ_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 6.200 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN D
    DIRECTION INPUT ;
    USE SIGNAL ;
  END D
  PIN CK
    DIRECTION INPUT ;
    USE SIGNAL ;
  END CK
  PIN Q
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Q
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END DFFQ_X1

MACRO DFFQ_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 8.500 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN D
    DIRECTION INPUT ;
    USE SIGNAL ;
  END D
  PIN CK
    DIRECTION INPUT ;
    USE SIGNAL ;
  END CK
  PIN Q
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Q
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END DFFQ_X2

MACRO BUF_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 3.500 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END BUF_X2

MACRO BUF_X4
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 5.200 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END BUF_X4

MACRO BUF_X8
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 8.300 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END BUF_X8

MACRO INV_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.100 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END INV_X1

MACRO INV_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.500 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END INV_X2

MACRO INV_X4
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.300 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END INV_X4

MACRO XNOR3_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 4.200 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN A3
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A3
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END XNOR3_X1

MACRO XNOR3_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 5.800 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN A3
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A3
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END XNOR3_X2

MACRO XOR2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 3.100 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END XOR2_X1

MACRO XNOR2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 3.100 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END XNOR2_X1

MACRO XOR2_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 4.200 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END XOR2_X2

MACRO XNOR2_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 4.200 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END XNOR2_X2

MACRO MUX2I_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 3.400 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN I0
    DIRECTION INPUT ;
    USE SIGNAL ;
  END I0
  PIN I1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END I1
  PIN S
    DIRECTION INPUT ;
    USE SIGNAL ;
  END S
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END MUX2I_X1

MACRO MUX2I_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 4.600 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN I0
    DIRECTION INPUT ;
    USE SIGNAL ;
  END I0
  PIN I1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END I1
  PIN S
    DIRECTION INPUT ;
    USE SIGNAL ;
  END S
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END MUX2I_X2

MACRO MUX2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 3.600 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN I0
    DIRECTION INPUT ;
    USE SIGNAL ;
  END I0
  PIN I1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END I1
  PIN S
    DIRECTION INPUT ;
    USE SIGNAL ;
  END S
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END MUX2_X1

MACRO AOI21_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.000 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN B
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END AOI21_X1

MACRO AOI21_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.700 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN B
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END AOI21_X2

MACRO OAI21_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.000 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN B
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END OAI21_X1

MACRO OAI21_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.700 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN B
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END OAI21_X2

MACRO AOI22_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.500 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN B1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B1
  PIN B2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END AOI22_X1

MACRO OAI22_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.500 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN B1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B1
  PIN B2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END OAI22_X1

MACRO NAND2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.400 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NAND2_X1

MACRO NAND2_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.900 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NAND2_X2

MACRO NAND2_X4
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.900 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NAND2_X4

MACRO NOR2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.400 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NOR2_X1

MACRO NOR2_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.900 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NOR2_X2

MACRO NAND3_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.000 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN A3
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A3
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NAND3_X1

MACRO NOR3_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.200 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN A3
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A3
  PIN ZN
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ZN
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END NOR3_X1

MACRO AND2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.000 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END AND2_X1

MACRO AND2_X2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.700 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END AND2_X2

MACRO OR2_X1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2.000 BY 0.900 ;
  SYMMETRY X Y ;
  SITE core9t ;
  PIN A1
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A1
  PIN A2
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A2
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
END OR2_X1

END LIBRARY
