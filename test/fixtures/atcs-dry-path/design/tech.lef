VERSION 5.8 ;
# synthetic technology LEF
END LIBRARY
