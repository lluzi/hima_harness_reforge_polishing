VERSION 5.8 ;
MACRO BUF1
END BUF1
MACRO BUF2
END BUF2
END LIBRARY
